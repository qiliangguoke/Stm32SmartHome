# Keil uVision project cgq.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cgq +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\bsp;..\User\bsp\inc;..\User\system
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_led.c bsp_timer.c bsp_beep.c bsp_key.c bsp_uart.c bsp_wwdg.c bsp_iosensor.c bsp_i2c_gpio.c bsp_sht30.c bsp_opt3001.c bsp_uart2.c bsp_co2.c bsp_pm2.5.c bsp_uart3.c bsp_relay.c bsp_fan.c
    ../User/bsp/inc/: bsp_led.h bsp_beep.h bsp_key.h bsp_uart.h bsp_wwdg.h bsp_iosensor.h bsp_i2c_gpio.h bsp_sht30.h bsp_opt3001.h bsp_uart2.h bsp_co2.h bsp_uart3.h bsp_pm2.5.h bsp_relay.h bsp_fan.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_iwdg.h stm32f10x_wwdg.h stm32f10x_tim.h stm32f10x_adc.h stm32f10x_exti.h
