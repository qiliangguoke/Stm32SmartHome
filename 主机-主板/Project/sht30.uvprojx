# Keil uVision project sht30.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sht30 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\bsp;..\User\bsp\inc;..\User\system;..\User\fonts;..\User\Logic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/src/: bsp_led.c bsp_timer.c bsp_beep.c bsp_key.c bsp_uart.c bap_iwdg.c bsp_wwdg.c bsp_tim_pwm.c bsp_tpad.c bsp_adc.c bsp_uart4.c bsp_co2.c bsp_iosensor.c bsp_nt35310_lcd.c bsp_i2c_gpio.c bsp_24c02.c bsp_sht30.c bsp_relay.c bsp_fan.c bsp_opt3001.c bsp_uart5.c bsp_pm2.5.c bsp_uart2.c
    ../User/bsp/inc/: bsp_led.h bsp_beep.h bsp_key.h bsp_uart.h bsp_iwdg.h bsp_wwdg.h bsp_tim_pwm.h bsp_tpad.h bsp_adc.h bsp_uart4.h bsp_co2.h bsp_iosensor.h bsp_nt35310_lcd.h bsp_i2c_gpio.h bsp_24c02.h bsp_sht30.h bsp_relay.h bsp_fan.h bsp_opt3001.h bsp_uart5.h bsp_pm2.5.h bsp_uart2.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Logic
    ../User/Logic/: sensor_Data_Proc.c sensor_Data_Proc.h usart1_cmd.c usart1_cmd.h
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_fsmc.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: stm32f10x_iwdg.h stm32f10x_wwdg.h stm32f10x_tim.h stm32f10x_adc.h stm32f10x_exti.h stm32f10x_fsmc.h
